<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pca10040\blank\iar\uart_pca10040.ewp</path>
    </project>
    <batchBuild />
</workspace>
