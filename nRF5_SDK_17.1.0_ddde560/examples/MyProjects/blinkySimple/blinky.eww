<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pca10040\blank\iar\blinky_pca10040.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pca10040\s132\iar\blinky_pca10040_s132.ewp</path>
    </project>
    <batchBuild />
</workspace>
