<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pca10040\blank\iar\pin_change_int_pca10040.ewp</path>
    </project>
    <batchBuild />
</workspace>
